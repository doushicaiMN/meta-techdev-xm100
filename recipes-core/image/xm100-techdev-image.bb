#
# Copyright (C) 2016-2020 Digi International.
#
require dey-image-graphical.inc

DESCRIPTION = "technology development team XM100 image with QT graphical libraries"

GRAPHICAL_CORE = "qt"
